# IAR project ProiectSOC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    lib/: LCDPanel.c
    ./: main.c
